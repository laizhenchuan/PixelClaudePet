# Keil uVision project STM32F407.uvprojx, settings and files
target STM32F407 (6220000::V6.22::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__NO_EMBEDDED_ASM
  c misc: -Wno-incompatible-library-redeclaration -Wno-unused-variable
  c include: User;Core;Core\Startup;STM32F4xx_StdPeriph_Driver\inc;STM32F4xx_StdPeriph_Driver\src;BSP\LED;BSP\KEY;BSP\W25Q128;BSP\LCD_ILI9341;BSP\UART;BSP\I2C;BSP\AT24C02;app
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    User/: main.c stm32f4xx_it.c stm32f4xx_conf.h
  group BSP
    BSP/LED/: bsp_LED.c
    BSP/W25Q128/: bsp_W25Q128.c
    BSP/UART/: bsp_UART.c
    BSP/LCD_ILI9341/: bsp_LCD_ILI9341.c
    BSP/KEY/: bsp_Key.c
    BSP/I2C/: bsp_I2CSoft.c
    BSP/AT24C02/: bsp_24C02.c
  group APP
    app/: pc_monitor.c pet_core.c pet_render.c pet_command.c pet_save.c
  group STARTUP
    Core/Startup/: startup_stm32f40xx.s
  group CMSIS
    Core/: stm32f4xx.h system_stm32f4xx.h system_stm32f4xx.c core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group STM32F4xx_StdPeriph_Driver
    STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
